<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>beamforming_payload_generator_cpp</key>
<param><key>id</key><value>beamforming_payload_generator_cpp_0</value></param>
<param><key>size</key><value>1</value></param>
<param><key>file_path</key><value>currently_not_used</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/genesys/workarea-gnuradio/gnuradio//gr-beamforming/examples/input.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/genesys/workarea-gnuradio/gnuradio//gr-beamforming/examples/output.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>comment</key><value>This module triggers the event 
  to generate payload
  to read file for CSI information</value></param>
<param><key>msg</key><value>pmt.PMT_T</value></param>
<param><key>period</key><value>10000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-15625e-6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_1_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_1_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_1_1_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>cons_config</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
# Configuration parameters for the device
modulations = [
    {
        "mod_name": "64QAM",
        "sym_map": [0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63],
        "cons_points": [(-1.080123+1.080123j), (-1.080123+0.771517j), (-1.080123+0.154303j), (-1.080123+0.46291j), (-1.080123-1.080123j), (-1.080123-0.771517j), (-1.080123-0.154303j), (-1.080123-0.46291j), (-0.771517+1.080123j), (-0.771517+0.771517j), (-0.771517+0.154303j), (-0.771517+0.46291j), (-0.771517-1.080123j), (-0.771517-0.771517j), (-0.771517-0.154303j), (-0.771517-0.46291j), (-0.154303+1.080123j), (-0.154303+0.771517j), (-0.154303+0.154303j), (-0.154303+0.46291j), (-0.154303-1.080123j), (-0.154303-0.771517j), (-0.154303-0.154303j), (-0.154303-0.46291j), (-0.46291+1.080123j), (-0.46291+0.771517j), (-0.46291+0.154303j), (-0.46291+0.46291j), (-0.46291-1.080123j), (-0.46291-0.771517j), (-0.46291-0.154303j), (-0.46291-0.46291j), (1.080123+1.080123j), (1.080123+0.771517j), (1.080123+0.154303j), (1.080123+0.46291j), (1.080123-1.080123j), (1.080123-0.771517j), (1.080123-0.154303j), (1.080123-0.46291j), (0.771517+1.080123j), (0.771517+0.771517j), (0.771517+0.154303j), (0.771517+0.46291j), (0.771517-1.080123j), (0.771517-0.771517j), (0.771517-0.154303j), (0.771517-0.46291j), (0.154303+1.080123j), (0.154303+0.771517j), (0.154303+0.154303j), (0.154303+0.46291j), (0.154303-1.080123j), (0.154303-0.771517j), (0.154303-0.154303j), (0.154303-0.46291j), (0.46291+1.080123j), (0.46291+0.771517j), (0.46291+0.154303j), (0.46291+0.46291j), (0.46291-1.080123j), (0.46291-0.771517j), (0.46291-0.154303j), (0.46291-0.46291j)]
    },
    {
        "mod_name": "32QAM",
        "sym_map": [0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31],
        "cons_points": [(-0.67082+1.118034j), (-0.223607+1.118034j), (-0.67082-1.118034j), (-0.223607-1.118034j), (-1.118034+0.67082j), (-1.118034+0.223607j), (-1.118034-0.67082j), (-1.118034-0.223607j), (-0.223607+0.67082j), (-0.223607+0.223607j), (-0.223607-0.67082j), (-0.223607-0.223607j), (-0.67082+0.67082j), (-0.67082+0.223607j), (-0.67082-0.67082j), (-0.67082-0.223607j), (0.67082+1.118034j), (0.223607+1.118034j), (0.67082-1.118034j), (0.223607-1.118034j), (1.118034+0.67082j), (1.118034+0.223607j), (1.118034-0.67082j), (1.118034-0.223607j), (0.223607+0.67082j), (0.223607+0.223607j), (0.223607-0.67082j), (0.223607-0.223607j), (0.67082+0.67082j), (0.67082+0.223607j), (0.67082-0.67082j), (0.67082-0.223607j)]
    },
    {
        "mod_name": "16QAM",
        "sym_map": [0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15],
        "cons_points": [(-0.948683+0.948683j), (-0.948683+0.316228j), (-0.948683-0.948683j), (-0.948683-0.316228j), (-0.316228+0.948683j), (-0.316228+0.316228j), (-0.316228-0.948683j), (-0.316228-0.316228j), (0.948683+0.948683j), (0.948683+0.316228j), (0.948683-0.948683j), (0.948683-0.316228j), (0.316228+0.948683j), (0.316228+0.316228j), (0.316228-0.948683j), (0.316228-0.316228j)]
    },
    {
        "mod_name": "8QAM",
        "sym_map": [0, 1, 2, 3, 4, 5, 6, 7],
        "cons_points": [(-1.224745+0.408248j), (-1.224745-0.408248j), (-0.408248+0.408248j), (-0.408248-0.408248j), (1.224745+0.408248j), (1.224745-0.408248j), (0.408248+0.408248j), (0.408248-0.408248j)]
    },
    {
        "mod_name": "QPSK",
        "sym_map": [0, 1, 2, 3],
        "cons_points": [(-0.707107+0.707107j), (-0.707107-0.707107j), (0.707107+0.707107j), (0.707107-0.707107j)]
    },
    {
        "mod_name": "BPSK",
        "sym_map": [0, 1],
        "cons_points": [(-1+0j), (1+0j)]
    }
]

switcher = {
               "64QAM" : 0,
               "32QAM" : 1,
               "16QAM" : 2,
               "8QAM"  : 3,
               "QPSK"  : 4,
               "BPSK"  : 5
           }


def get_points(modulation_name):


    index = switcher.get(modulation_name)
    # print(index)
    # return modulations[index].get("sym_map"), modulations[index].get("cons_points")
    return modulations[index].get("cons_points")

</value></param>
<param><key>comment</key><value>Python file imported to define constellation points</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cons_config.get_points("8QAM")</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cons_config.get_points("16QAM")</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_1</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cons_config.get_points("QPSK")</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_1_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cons_config.get_points("BPSK")</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_1_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cons_config.get_points("32QAM")</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_1_0_1</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cons_config.get_points("64QAM")</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>64</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>IFFT</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>beamforming_payload_generator_cpp_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>16QAM_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>beamforming_payload_generator_cpp_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1_1</sink_block_id><source_key>32QAM_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>beamforming_payload_generator_cpp_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1_2</sink_block_id><source_key>64QAM_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>beamforming_payload_generator_cpp_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>8QAM_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>beamforming_payload_generator_cpp_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1_0</sink_block_id><source_key>BPSK_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>beamforming_payload_generator_cpp_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>QPSK_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>beamforming_payload_generator_cpp_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>blocks_repack_bits_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1_1</source_block_id><sink_block_id>blocks_repack_bits_bb_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1_2</source_block_id><sink_block_id>blocks_repack_bits_bb_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1_1_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_1_0_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_1_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_1_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_1_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
