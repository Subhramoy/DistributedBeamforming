<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>offline_corr_test_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_files_path</value></param>
<param><key>value</key><value>"/home/genesys/workarea-gnuradio/gnuradio/gr-beamforming/examples/data"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trainingSignal_size</value></param>
<param><key>value</key><value>16456</value></param>
</block>
<block>
<key>beamforming_correlate_and_tag_py</key>
<param><key>id</key><value>beamforming_correlate_and_tag_py_0</value></param>
<param><key>comment</key><value>Always returns Xcorr output of
 the last Gold Sequence</value></param>
<param><key>cor_method</key><value>1</value></param>
<param><key>feedback_type</key><value>0</value></param>
<param><key>frame_len</key><value>trainingSignal_size + 400 + 256* 64 + 100</value></param>
<param><key>seq_len</key><value>trainingSignal_size</value></param>
<param><key>num_Tx</key><value>2</value></param>
<param><key>file_path</key><value>data_files_path + "/trainingSig"</value></param>
</block>
<block>
<key>beamforming_filter_payload_py</key>
<param><key>id</key><value>beamforming_filter_payload_py_0</value></param>
<param><key>tag_name</key><value>payload</value></param>
</block>
<block>
<key>beamforming_matlab_file_payload_py</key>
<param><key>id</key><value>beamforming_matlab_file_payload_py_0</value></param>
<param><key>file_path</key><value>data_files_path + "/trainingSig1"</value></param>
</block>
<block>
<key>beamforming_matlab_file_payload_py</key>
<param><key>id</key><value>beamforming_matlab_file_payload_py_0_0</value></param>
<param><key>file_path</key><value>data_files_path + "/trainingSig2"</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>400</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0</value></param>
<param><key>interp</key><value>256*64</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0_0</value></param>
<param><key>interp</key><value>256*64</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_1</value></param>
<param><key>interp</key><value>100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_1_0</value></param>
<param><key>interp</key><value>100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_2</value></param>
<param><key>interp</key><value>400</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1</value></param>
<param><key>lengths</key><value>trainingSignal_size, 400 , 256* 64 , 100</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1_0</value></param>
<param><key>lengths</key><value>1000 , 256* 64</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1_1</value></param>
<param><key>lengths</key><value>trainingSignal_size, 400 , 256* 64 , 100</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>900e6</value></param>
<param><key>fftsize</key><value>256*8</value></param>
<param><key>name</key><value>Rx Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_1_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IQ</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Corr Output</value></param>
<param><key>name</key><value>Rx Signal</value></param>
<param><key>size</key><value>200000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_1_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IQ</value></param>
<param><key>name</key><value>XCor</value></param>
<param><key>size</key><value>200000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_1_0_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IQ</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Corr Output</value></param>
<param><key>name</key><value>Retrieved Payload</value></param>
<param><key>size</key><value>200000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>flow</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>flow</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>zero_padding_0_0_0</value></param>
<param><key>const</key><value>0.1-0.1j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>zero_padding_0_0_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>zero_padding_0_0_0_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>zero_padding_0_0_0_0_1</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>zero_padding_0_0_0_1</value></param>
<param><key>const</key><value>0.1-0.1j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>beamforming_filter_payload_py_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_filter_payload_py_0</source_block_id><sink_block_id>blocks_stream_mux_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>beamforming_matlab_file_payload_py_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_matlab_file_payload_py_0_0</source_block_id><sink_block_id>blocks_stream_mux_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_1_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_1</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_1_0</source_block_id><sink_block_id>blocks_stream_mux_1_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_2</source_block_id><sink_block_id>blocks_stream_mux_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>beamforming_correlate_and_tag_py_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zero_padding_0_0_0</source_block_id><sink_block_id>blocks_repeat_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zero_padding_0_0_0_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zero_padding_0_0_0_0</source_block_id><sink_block_id>blocks_repeat_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zero_padding_0_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zero_padding_0_0_0_0_1</source_block_id><sink_block_id>blocks_repeat_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zero_padding_0_0_0_0_1</source_block_id><sink_block_id>blocks_repeat_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zero_padding_0_0_0_1</source_block_id><sink_block_id>blocks_repeat_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
