<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>airbeam_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_files_path</value></param>
<param><key>value</key><value>"/home/genesys/workarea-gnuradio/gnuradio/gr-beamforming/examples/data"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trainingSignal_size</value></param>
<param><key>value</key><value>16456</value></param>
</block>
<block>
<key>beamforming_correlate_and_tag_py</key>
<param><key>id</key><value>beamforming_correlate_and_tag_py_0</value></param>
<param><key>cor_method</key><value>1</value></param>
<param><key>feedback_type</key><value>0</value></param>
<param><key>frame_len</key><value>trainingSignal_size + 400 + 256* 64 + 100</value></param>
<param><key>seq_len</key><value>trainingSignal_size</value></param>
<param><key>num_Tx</key><value>3</value></param>
<param><key>file_path</key><value>data_files_path + "/trainingSig"</value></param>
</block>
<block>
<key>beamforming_feedback_calculation_py</key>
<param><key>id</key><value>beamforming_feedback_calculation_py_0</value></param>
<param><key>data_path</key><value>data_files_path + "/trainingSig"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_len</key><value>trainingSignal_size + 400 + 256* 64 + 100</value></param>
<param><key>seq_len</key><value>trainingSignal_size</value></param>
<param><key>number_of_Tx</key><value>1</value></param>
</block>
<block>
<key>beamforming_filter_payload_py</key>
<param><key>id</key><value>beamforming_filter_payload_py_0</value></param>
<param><key>tag_name</key><value>payload</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/payload.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/corr.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>925e6</value></param>
<param><key>fftsize</key><value>256*8</value></param>
<param><key>name</key><value>Tx Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_1_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IQ</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Corr Output</value></param>
<param><key>name</key><value>Tx Signal</value></param>
<param><key>size</key><value>200000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_1_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IQ</value></param>
<param><key>name</key><value>XCor</value></param>
<param><key>size</key><value>200000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_1_0_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IQ</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Corr Output</value></param>
<param><key>name</key><value>Tx Signal</value></param>
<param><key>size</key><value>200000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>400e3</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(925e6,1e6)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>70</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=3189F54"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>beamforming_feedback_calculation_py_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>beamforming_filter_payload_py_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_correlate_and_tag_py_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamforming_feedback_calculation_py_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>beamforming_filter_payload_py_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>beamforming_correlate_and_tag_py_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
